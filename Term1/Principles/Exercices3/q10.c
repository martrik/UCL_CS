#include "stdio.h"

char one[5][3] = {{' ','*',' '}, {'*','*',' '},
{' ','*',' '}, {' ','*',' '}, {'*','*','*'}};

char two[5][6] = {{'*','*','*','*','*'}, {' ',' ',' ',' ', '*'},
{'*','*','*','*','*'}, {'*',' ',' ',' ', ' '}, {'*','*','*','*','*'}};

char three[5][6] = {{'*','*','*','*','*'}, {' ',' ',' ',' ', '*'},
{'*','*','*','*','*'}, {' ',' ',' ',' ', '*'}, {'*','*','*','*','*'}};

char four[5][6] = {{'*',' ',' ',' ','*'}, {'*',' ',' ',' ', '*'},
{'*','*','*','*','*'}, {' ',' ',' ',' ', '*'}, {' ',' ',' ',' ','*'}};

char five[5][6] = {{'*',' ',' ',' ','*'}, {'*',' ',' ',' ', '*'},
{'*','*','*','*','*'}, {' ',' ',' ',' ', '*'}, {' ',' ',' ',' ','*'}};

char six[5][6] = {{'*',' ',' ',' ','*'}, {'*',' ',' ',' ', '*'},
{'*','*','*','*','*'}, {' ',' ',' ',' ', '*'}, {' ',' ',' ',' ','*'}};

char seven[5][6] = {{'*',' ',' ',' ','*'}, {'*',' ',' ',' ', '*'},
{'*','*','*','*','*'}, {' ',' ',' ',' ', '*'}, {' ',' ',' ',' ','*'}};

char eight[5][6] = {{'*',' ',' ',' ','*'}, {'*',' ',' ',' ', '*'},
{'*','*','*','*','*'}, {' ',' ',' ',' ', '*'}, {' ',' ',' ',' ','*'}};

char nine[5][6] = {{'*',' ',' ',' ','*'}, {'*',' ',' ',' ', '*'},
{'*','*','*','*','*'}, {' ',' ',' ',' ', '*'}, {' ',' ',' ',' ','*'}};

void printDigitRow(int digit, int row) {
  if (digit == 1) printf
}

int main() {
  int number = 0;
  scanf("%d", &number);

  int digits = 0;
  int copyNumber = number;
  while (copyNumber >= 10) {
    digits++;
    copyNumber /= 10;
  }
  digits++;

  int numberArray[digits-1];
  for (int i = 0; i<digits; i++) {
    numberArray[digits-i-1] = number%10;
    number /= 10;
  }

  for (int i = 0; i<5; i++) {
    for (int t = 0; t<digits; t++) {
      printDigitRow(numberArray[digits], i);
      printf(" ");
    }
    printf("\n");
  }

  return 0;
}
